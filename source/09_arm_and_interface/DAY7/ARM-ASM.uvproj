# Keil uVision project ARM-ASM.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: ARM-ASM
  group Source Group 1
    ./: arm-asm.s test.c
